options:
  parameters:
    author: joakim
    generate_options: qt_gui
    id: receive
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: '88200'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joakim/dev/hs-ctf-22/misc/walkie-talkie/received.iq
    repeat: 'True'
    type: complex
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_file_source_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
