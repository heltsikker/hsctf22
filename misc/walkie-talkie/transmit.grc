options:
  parameters:
    author: joakim
    generate_options: qt_gui
    id: transmit
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    quad_rate: '88200'
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '44100'
    fh: '-1.0'
    max_dev: 30e3
    quad_rate: '88200'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/joakim/dev/hs-ctf-22/misc/walkie-talkie/received.iq
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/joakim/dev/hs-ctf-22/misc/walkie-talkie/walkie-talkie.wav
    repeat: 'False'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.3'
    seed: '0'
    taps: 1.0 + 1.0j
  states: {}

connections:
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [analog_wfm_tx_0, '0', channels_channel_model_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [channels_channel_model_0, '0', analog_wfm_rcv_0, '0']
- [channels_channel_model_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
